# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTE\Device\S32K144HAxxxLHx;..\S32K;..\FreeRTOS\Include;..\FreeRTOS\Port\MemMang;..\FreeRTOS\Port\RVDS\ARM_CM4F;..\App;..\platform\drivers\inc;..\platform\drivers\src\pins
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: .\RTE\Device\S32K144HAxxxLHx\S32K144_64_flash.sct
  group System
    ../System/: main.c
  group FreeRTOS/Src
    ../FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/Port/MemMang/: heap_4.c
    ../FreeRTOS/Port/RVDS/ARM_CM4F/: port.c
  group App
    ../App/: FreeRTOSConfig.h
  group Dirvers
    ../platform/drivers/src/pins/: pins_driver.c pins_port_hw_access.c
software components: CMSIS:CORE 5.1.2, Device:Startup 2.0.0
