# Keil uVision project S32k_Demo.uvprojx, settings and files
target S32K_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: S32K144HAxxxLHx NXP
  pack: Keil.S32_SDK_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00007000) IRAM2(0x1FFF8000,0x00008000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S32k_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Platform;..\..\Platform\devices;..\..\Platform\devices\common;..\..\Platform\devices\S32K144\include;..\..\Platform\devices\S32K144\startup;..\..\System\Rtos\FreeRTOS_S32K\include;..\..\System\Rtos\FreeRTOS_S32K\portable\ARM_CM4F;..\..\System\Rtos
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x7000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  scatter file: ..\..\Platform\devices\S32K144\linker\arm\S32K144_64_flash.sct
  group APP
    ../../System/Rtos/: FreeRTOSConfig.h
  group Rtos/src
    ../../System/Rtos/FreeRTOS_S32K/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Rtos/Port
    ../../System/Rtos/FreeRTOS_S32K/portable/ARM_CM4F/: port.c
    ../../System/Rtos/FreeRTOS_S32K/portable/MemMang/: heap_4.c
  group System
    ../../System/EcuM/: EcuM.c
  group StartUp
    ../../Platform/devices/: startup.c
    ../../Platform/devices/S32K144/startup/arm/: startup_S32K144.s
    ../../Platform/devices/S32K144/startup/: system_S32K144.c
